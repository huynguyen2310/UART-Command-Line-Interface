# Keil uVision project customUART.uvprojx, settings and files
target customUART (6190000::V6.19::ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: customUART.axf +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L152xE
  c include: ../Inc;    ../Drivers/STM32L1xx_HAL_Driver/Inc;    ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;    ../Drivers/CMSIS/Include;    ..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group App
    ../App/: cus_uart.c cus_uart.h gettemp.h gettemp.c response_ci.c response_ci.h lm35.c lm35.h cli_command.c cli_command.h
  group Application/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 5.6.0
